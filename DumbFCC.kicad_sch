File: DumbFCC.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: First draft of schematic
Other:
- removed sheet Power - Sequencing
